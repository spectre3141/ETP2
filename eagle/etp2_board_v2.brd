# Repository spectre3141/ETP2

File README.md:

# ETP2

ETP2_Layout files and c code for the atmega328pb

## EAGLE design eagle/etp2_board_v2.brd

Parts:
C1, C7, C11, C12, C17, C18, C23, C24, C33, C34, C35, C36, C37, C38, C39, C41, C42: 100nF; C0805
C2, C3, C13, C19: 160pF; C0805
C4, C6, C8, C10, C14, C16, C20, C22: 1uF; C0805
C5, C9, C15, C21, C31, C32: 10nF; C0805
C25: CPOL-EUE3.5-8; E3,5-8
C26, C43, C44: C-EUC0805; C0805
C27, C28, C29, C30: 100uF; E3,5-8
C40: 470pF; C0805
D1, D2, D3, D4: TS4148RY; D0805
D5, D6, D7, D8, D9, D10, D11: SS13L; SUB-SMA
IC1, IC4, IC5, IC7: MCP6561; SOT23-5
IC2, IC3, IC6, IC8: SN74LVC2G02; DCT_R-PDSO-G8
IC9, IC10: LM2674; SO08
IC11: TXS0102; SSOP08
IC12: TS4871; SO08
JP1, JP2, JP3, JP4: JP1E; JP1
JP5: PINHD-2X3; 2X03
JP6: PINHD-2X2; 2X02
L1, L2, L3, L4: 680uH; POWER-CHOKE_WE-PD
L5, L6: 220uH; SDR0604
M1: RN42_BLUETOOTH
Q1: K12A
R1, R2, R9, R13: 100k; R0805
R3, R6, R10, R14: 1; R1206
R4, R7, R11, R15: 1k; R0805
R5, R12, R16: 8.2k; R0805
R8: 8,2k; R0805
R17, R20: 10k; R0805
R19: 20k; R0805
R21, R22: 22k; R0805
T1, T2, T3, T4: BUK98150-55A; SOT223
TP1, TP2, TP3, TP4: TPSQPAD1-17; P1-17
U1: ATMEGA328PB-AU; QFP80P900X900X120-32N
X1, X4: BLOCK_2PIN; TERMINAL_BLOCK_MC000036
X2, X3: TERMINAL_BLOCK_MC000036

Connections:
+3V3: C29.+, C37.2, C38.1, IC9.4 (FB), IC11.3 (VCCA), IC11.6 (OE), L6.2, M1.4 (GPIO7), M1.11 (VDD)
+5V: C1.1, C7.2, C11.2, C12.1, C17.2, C18.1, C23.2, C24.1, C30.+, C33.2, C34.2, C35.2, C36.1, C39.1, IC1.2 (V+), IC2.8 (VCC), IC3.8 (VCC), IC4.2 (V+), IC5.2 (V+), IC6.8 (VCC), IC7.2 (V+), IC8.8 (VCC), IC10.4 (FB), IC11.7 (VCCB), IC12.6 (VCC), JP5.2, L5.2, R17.2, R20.2, U1.4 (VCC), U1.18 (AVCC), U1.20 (AREF)
+24V: C4.2, C8.2, C14.2, C20.2, C25.+, C26.1, C27.+, C28.+, D11.C, IC9.7 (VIN), IC10.7 (VIN), JP1.2, JP2.2, JP3.2, JP4.2
AUDIO: C42.2, R21.1, R22.1
DAC_0: R5.2, U1.13 (PB1)
DAC_1: R12.2, U1.14 (PB2)
DAC_2: R8.2, U1.32 (PD2)
DAC_3: R16.2, U1.31 (PD1)
GND: C1.2, C2.1, C3.1, C4.1, C5.2, C7.1, C8.1, C9.2, C11.1, C12.2, C13.1, C14.1, C15.2, C17.1, C18.2, C19.1, C20.1, C21.2, C23.1, C24.2, C25.-, C26.2, C27.-, C28.-, C29.-, C30.-, C33.1, C34.1, C35.1, C36.2, C37.1, C38.2, C39.2, C41.1, C43.1, C44.2, D1.C, D2.C, D3.C, D4.C, D6.A, D7.A, IC1.5 (V-), IC2.4 (GND), IC3.4 (GND), IC4.5 (V-), IC5.5 (V-), IC6.4 (GND), IC7.5 (V-), IC8.4 (GND), IC9.6 (GND), IC10.6 (GND), IC11.2 (GND), IC12.7 (GND), JP5.6, M1.1 (GND_1), M1.12 (GND_2), M1.28 (GND_3), M1.29 (GND_4), R1.2, R2.2, R3.2, R6.2, R9.2, R10.2, R13.2, R14.2, TP1.TP, U1.5 (GND), U1.21 (GND), X1.1
MISO/RX: JP5.1, JP6.4, U1.16 (PB4)
MOSI/TX: JP5.4, JP6.2, U1.15 (PB3)
unnamed: IC3.2 (B), IC3.3 (Y), R1.1, T2.1 (G)
unnamed: IC3.5 (A), IC3.7 (Y)
unnamed: IC2.2 (B), IC2.3 (Y), R2.1, T1.1 (G)
unnamed: IC1.1 (OUT), IC3.6 (B)
unnamed: D8.A, L1.1, T2.2 (D), T2.4 (D)
unnamed: IC2.5 (A), IC2.7 (Y)
unnamed: IC2.6 (B), IC4.1 (OUT)
unnamed: D5.A, L2.1, T1.2 (D), T1.4 (D)
unnamed: C5.1, D1.A, IC4.4 (IN-), R5.1
unnamed: C2.2, IC1.3 (IN+), R7.2
unnamed: C9.1, D2.A, IC1.4 (IN-), R8.1
unnamed: R3.1, R4.1, T1.3 (S)
unnamed: C3.2, IC4.3 (IN+), R4.2
unnamed: R6.1, R7.1, T2.3 (S)
unnamed: IC6.2 (B), IC6.3 (Y), R9.1, T3.1 (G)
unnamed: IC6.5 (A), IC6.7 (Y)
unnamed: IC5.1 (OUT), IC6.6 (B)
unnamed: D9.A, L3.1, T3.2 (D), T3.4 (D)
unnamed: C13.2, IC5.3 (IN+), R11.2
unnamed: C15.1, D3.A, IC5.4 (IN-), R12.1
unnamed: R10.1, R11.1, T3.3 (S)
unnamed: IC8.2 (B), IC8.3 (Y), R13.1, T4.1 (G)
unnamed: IC8.5 (A), IC8.7 (Y)
unnamed: IC7.1 (OUT), IC8.6 (B)
unnamed: D10.A, L4.1, T4.2 (D), T4.4 (D)
unnamed: C19.2, IC7.3 (IN+), R15.2
unnamed: C21.1, D4.A, IC7.4 (IN-), R16.1
unnamed: R14.1, R15.1, T4.3 (S)
unnamed: D11.A, X1.2
unnamed: C31.1, IC10.1 (CB)
unnamed: C31.2, D6.C, IC10.8 (VSW), L5.1
unnamed: IC11.4 (A2), M1.14 (UART_TX)
unnamed: C32.2, D7.C, IC9.8 (VSW), L6.1
unnamed: IC11.5 (A1), M1.13 (UART_RX)
unnamed: C32.1, IC9.1 (CB)
unnamed: IC11.8 (B1), JP6.1
unnamed: IC11.1 (B2), JP6.3
unnamed: C40.2, C42.1, IC12.4 (VIN-), R19.1
unnamed: IC12.8 (VOUT2), X4.1
unnamed: C40.1, IC12.5 (VOUT1), R19.2, X4.2
unnamed: R21.2, U1.10 (PD6)
unnamed: C41.2, IC12.2 (BP), IC12.3 (VIN+)
unnamed: R22.2, U1.9 (PD5)
unnamed: C43.2, Q1.2, U1.7 (PB6)
unnamed: TP2.TP, U1.24 (PC1)
unnamed: TP3.TP, U1.25 (PC2)
unnamed: TP4.TP, U1.26 (PC3)
unnamed: C44.1, Q1.1, U1.8 (PB7)
RESET: JP5.5, R17.1, U1.29 (PC6)
SCK: JP5.3, U1.17 (PB5)
STANDBY: IC12.1 (SB), R20.1, U1.2 (PD4)
START: IC2.1 (A), IC3.1 (A), IC6.1 (A), IC8.1 (A), U1.30 (PD0)
X2_1: C6.2, D5.C, JP1.1, X2.1
X2_2: C6.1, L2.2, X2.2
X2_3: C16.2, D9.C, JP3.1, X2.3
X2_4: C16.1, L3.2, X2.4
X3_1: C10.2, D8.C, JP2.1, X3.1
X3_2: C10.1, L1.2, X3.2
X3_3: C22.2, D10.C, JP4.1, X3.3
X3_4: C22.1, L4.2, X3.4

Notes on the sheet:
5V Regulator
3V3 Regulator

Board: 2 copper layers, 114.3 x 86.0 mm, 115 parts (0 on the bottom side), 71 nets.

## EAGLE design ATmega_test_board.brd

Parts:
C1, C2, C3, C4: 100n; C0805
C5: 100u; E3,5-8
ISP: PINHD-2X3; 2X03
JP1: PINHD-1X8; 1X08
R1: 10k; R1206
U1: ATMEGA328PB-AU; QFP80P900X900X120-32N
X1: Mini USB Type B; 32005-301
X2: 20PIN_MALE_CONNECTOR

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.+, ISP.2, R1.1, U1.4 (VCC), U1.18 (AVCC), U1.20 (AREF), X1.1, X2.18
DAC: JP1.2, U1.10 (PD6), X2.11
GND: C1.2, C2.2, C3.2, C4.2, C5.-, ISP.6, U1.5 (GND), U1.21 (GND), X1.5
MISO: ISP.1, U1.16 (PB4)
MOSI: ISP.4, U1.15 (PB3)
PB0: U1.12 (PB0)
PB1: JP1.3
PB2: JP1.4, U1.14 (PB2)
PB6: U1.7 (PB6)
PB7: U1.8 (PB7)
PD0: JP1.5, U1.30 (PD0)
PD1: JP1.6, U1.31 (PD1)
PD2: JP1.7, U1.32 (PD2)
PD3: JP1.8, U1.1 (PD3)
PD4: U1.2 (PD4)
PD5: U1.9 (PD5)
PWM: X2.1, X2.19
RESET: ISP.5, R1.2, U1.29 (PC6)
SCK: ISP.3, U1.17 (PB5)
START: JP1.1, U1.13 (PB1), X2.10

Board: 2 copper layers, 45.7 x 45.4 mm, 11 parts (0 on the bottom side), 14 nets.

## Commit log

2018-03-10 Test
2018-03-10 V0.1
    V0.1
2018-03-16 3/4 done
2018-03-16 initial upload of testboard
2018-03-16 LED Driver done
2018-03-16 C Fix
2018-03-16 C fix cont.
2018-03-16 test windoof
2018-03-17 DRC ok TODO: Text, review, test fit
2018-03-18 Text fixed /Audio missing
2018-03-19 Added libs
2018-03-19 Fixed consientency error
2018-03-19 Moodlight.lbr
2018-03-19 AUDIO/STANDBY ADDED
2018-03-20 Added new Pin lib
2018-03-21 Fixed LM2672
2018-03-23 Moved Audio amp
2018-03-23 V1.0
2018-04-29 moved eagle files to new folder
2018-04-29 added c code for atmega328pb
2018-04-30 added alarm c flies
2018-04-30 PWM for alarm
2018-05-04 BLAAARG!!
2018-05-06 ICH BRUCH EN EIS!!! LOOOOS GIB MIR EN EIS!!
2018-05-08 Timer 2 config
2018-05-08 added directories "androidapp" & "datasheets"
2018-05-08 alarm fucntion modified
2018-05-08 more changes
2018-05-10 alarm uses internal clock atm
2018-05-13 sache
2018-05-14 gui undso
2018-05-15 color and stuff
2018-05-15 LedActivity finished
2018-05-16 alarm working internal clock
2018-05-16 some changes to the bluetooth stuff
2018-05-16 UART gedöns
2018-05-18 fixed uart
2018-05-18 UART fully working
2018-05-21 > implemented the alarm function > set app icon
2018-05-21 added layouts to repository
2018-05-21 added icon (72x72)
2018-05-21 added the other icons (48x48), (96x96), (144x144)
2018-05-21 added missing classes and interfaces
2018-05-21 disabled screen rotation
2018-05-21 alarm zeugs
2018-05-22 added apk directory/file
2018-05-22 added new apk release file
2018-05-22 alarm uart
2018-05-22 stuff
2018-05-22 added release directory
2018-05-22 deleted apk
2018-05-22 added user manual to repository
2018-05-22 added stuff
2018-05-22 FUNKTIONIER!!
2018-05-22 blarg
2018-05-22 test version
2018-05-22 namechange might work now ..
2018-05-28 alarm fixes
2018-05-28 v2_board
2018-05-28 maybe
2018-05-28 alarm
2018-05-28 board version 2
2018-05-28 updated icon
2018-05-28 final icon
2018-05-28 version 2 done
2018-06-11 added docu of extra feature
2018-06-12 comments
2018-06-12 blargggh
2018-06-12 blablabla
2018-06-12 Hardware decrition
2018-06-13 Hardware test procedure
2018-06-13 bitconnect
2018-06-28 added presentations
2018-06-28 updated apk
2018-06-29 super uber secret update!
2018-06-29 super secret was never there
2023-01-02 ideeeeen
2023-01-09 Rename Ideen: to Ideen
2023-01-09 REEEEEEEEEEEEEEEEEEEEEEEEEEE
2023-01-10 display und buddne
